Commit message: after pos_recording

File: src/robotti_1/urdf/robotti_1.urdf (robot description, URDF)
Before this commit: robot robotti_1, 13 links, 12 joints
Links:
- link camera_link: mass None -> 0.001
